/**
 * @file      shellesp.cpp
 * @copyright Jason Howard. All rights reserved.
 *
 * SPDX-License-Identifier: MIT
 * See LICENSE file in the project root folder for license information.
 *
 * Target-only parts of the shell: the linker-built command table, the
 * shell as /bin/sh, and what an interactive one starts with.
 */

#include <sdkconfig.h>
#include <bmds/boot.h>
#include <bmds/builtinprograms.h>
#include <bmds/shell.h>
#include <bmds/string.h>
#include <bmds/sysconf.h>
#include <bmds/system.h>

// Bounds of the sorted command table, generated by SURROUND(bmds_cmd) in linker.lf.
extern "C" const bmds::Command _bmds_cmd_start[];
extern "C" const bmds::Command _bmds_cmd_end[];

BMDS_NAMESPACE_BEGIN

int Shell::programMain(const BuiltinProgram::Context &context) {
        return runAsProgram(context, registeredCommands(), CONFIG_BMDS_SHELL_STACK_BYTES, "sh");
}

int shellAppletMain(const BuiltinProgram::Context &context) {
        return Shell::runAsProgram(context, Shell::registeredCommands(), CONFIG_BMDS_SHELL_STACK_BYTES,
                                   context.program);
}

// The shell as a program: /bin/sh, and /bin/bash for scripts that ask for it (devplan/programs.md §17).
BMDS_PROGRAM(bash, Shell::programMain, CONFIG_BMDS_SHELL_STACK_BYTES)
BMDS_PROGRAM(sh, Shell::programMain, CONFIG_BMDS_SHELL_STACK_BYTES)

Span<const Command> Shell::registeredCommands() {
        return Span<const Command>(_bmds_cmd_start, static_cast<size_t>(_bmds_cmd_end - _bmds_cmd_start));
}

namespace {

        // A new shell's PATH (devplan/sysconf.md §8): where commands that aren't built-ins are
        // looked for (name, name.elf, name.sh). Shells running keep theirs.
        constexpr const char DefaultPath[] = "/bin:/rom/bin:/sd0/p0/bin";

        BMDS_SYSCONF(shellPath, "shell/path", Config::Type::String, DefaultPath,
                     "A new shell's PATH: directories separated by :", 0, 1024, nullptr, nullptr)

} // namespace

void Shell::prepareInteractive(bool login) {
        // A login shell starts at boot: its first prompt comes after the boot report. Boot
        // always completes, so there is nothing to time out on.
        if (login) (void)Boot::waitUntilComplete(WaitForever);
        Variables &vars = _state.vars;
        const auto inherited = [&](StringView name) {
                const Variables::Entry *e = vars.find(name);
                return e != nullptr && (e->flags & Variables::Exported) != 0;
        };
        prepareProgram();
        (void)vars.set("BMDS_VERSION", System::info().bmdsVersion);
        // The chip's serial number, for programs; the host name as bash keeps it (devplan/notifications.md §2).
        (void)vars.set("BMDS_SERIAL", System::serial());
        (void)vars.addFlags("BMDS_SERIAL", Variables::Exported);
        {
                char name[HostName::MaxBytes + 1];
                (void)SysConf::hostname(name);
                (void)vars.set("HOSTNAME", name);
        }
        // A colored prompt with the directory; the console fits the color to its terminal.
        if (!inherited("PS1")) (void)vars.set("PS1", "\\[\\e[1;32m\\]\\h\\[\\e[0m\\]:\\[\\e[1;34m\\]\\w\\[\\e[0m\\]> ");
        return;
}

// Any new shell, interactive or not (`sh -c` over SSH): HOME and PATH unless inherited.
void Shell::prepareProgram() {
        Variables &vars = _state.vars;
        const auto inherited = [&](StringView name) {
                const Variables::Entry *e = vars.find(name);
                return e != nullptr && (e->flags & Variables::Exported) != 0;
        };
        // HOME is /home, the link to the user's home (devplan/sysconf.md §7), unless inherited.
        if (!inherited("HOME")) {
                (void)vars.set("HOME", "/home");
                (void)vars.addFlags("HOME", Variables::Exported);
        }
        // PATH is the system configuration's shell/path, unless inherited.
        if (!inherited("PATH")) {
                String path;
                if (SysConf::get("shell/path", path).isError()) (void)path.assign(DefaultPath);
                (void)vars.set("PATH", path.view());
                (void)vars.addFlags("PATH", Variables::Exported);
        }
        return;
}

// The system's host name, read each time a prompt is drawn: a change shows at the next.
void Shell::hostName(String &out) const {
        char         name[HostName::MaxBytes + 1];
        const size_t n = SysConf::hostname(name);
        (void)out.assign(StringView(name, n));
        return;
}

BMDS_NAMESPACE_END
